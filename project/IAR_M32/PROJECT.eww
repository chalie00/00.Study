<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\PROJECT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\Example\STM32F103-master\Example_SysTick\Systick.ewp</path>
  </project>
  <batchBuild/>
</workspace>


